# IAR project STM32_F107_uCOS_5.30.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  ICCARM.CCDefines: STM32F10X_CL; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; netapp; ..\BSP; ..\..\CPU\ST\STM32\inc; ..\..\CPU\ST\ETH\inc; ..\..\CPU\CMSIS\Core\CM3; ..\..\uC-CPU\ARM-Cortex-M3\IAR; ..\..\uC-LIB; ..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\uCOS-II\Source; ..\..\uC-CPU; ..\..\lwIP\port\include; ..\..\lwIP\port\include\; ..\..\lwIP\port\include\netif; ..\..\lwIP\src\include; ..\..\lwIP\src\include\ipv4; ..\..\lwIP\src\include\lwip
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: STM32_F107_uCOS_5.30.hex
  ILINK.IlinkOutputFile: STM32_F107_uCOS_5.30.out
  ILINK.IlinkIcfFile: ..\BSP\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP/General
    ./: app.c app_cfg.h app_vect_v5.c includes.h os_cfg.h
  group APP/NetApp
    netapp/: netdatapack.c netio.c sample_http.c sample_TTCP.c tcpclient.c tcpecho.c tcpmultiserver.c tcpserver.c tcpserver2.c udpclient.c udpecho.c udpserver.c
  group APP/ST
    ./: stm32f10x_conf.h
  group BSP/General
    ../BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c stm32f10x_flash.icf
  group BSP/LCD
    ../BSP/: stm3210c_eval_lcd.c stm3210c_eval_lcd.h
  group CMSIS
    ../../CPU/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ../../CPU/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_cl.s
  group Doc
    ../../: ReadMe.txt
  group ETHLib/inc
    ../../CPU/ST/ETH/inc/: stm32_eth.h
  group ETHLib/src
    ../../CPU/ST/ETH/src/: stm32_eth.c
  group FWLib/inc
    ../../CPU/ST/STM32/inc/: misc.h stm32f10x_adc.h stm32f10x_can.h stm32f10x_dbgmcu.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_rcc.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h
  group FWLib/inc/Unused
    ../../CPU/ST/STM32/inc/: stm32f10x_bkp.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dma.h stm32f10x_fsmc.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_wwdg.h
  group FWLib/src
    ../../CPU/ST/STM32/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group FWLib/src/Unused
    ../../CPU/ST/STM32/src/: stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_wwdg.c
  group lwIP/Port
    ../../lwIP/port/netif/: ethernetif.c
    ../../lwIP/port/: lwIP.c sys_arch.c
    ../../lwIP/port/include/: lwipopts.h
  group lwIP/Source/api
    ../../lwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwIP/Source/core
    ../../lwIP/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group lwIP/Source/core/ipv4
    ../../lwIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwIP/Source/netif
    ../../lwIP/src/netif/: etharp.c
  group uC/CPU
    ../../uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
    ../../uC-CPU/: cpu_def.h
  group uC/LIB
    ../../uC-LIB/: lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/LIB/Ports
    ../../uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uC/OS-II/Port
    ../../uCOS-II/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/OS-II/Source
    ../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
